options:
  parameters:
    generate_options: qt_gui
    id: Example1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Atten
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '10'
    stop: ' 89.75'
    value: '0'
  states: {}
- name: LOFreq
  id: variable
  parameters:
    value: int(5.3e9)
  states: {}
- name: USB
  id: variable
  parameters:
    value: '"usb:1.9.5"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.6e6)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: Atten
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: LOFreq
    samplerate: samp_rate
    type: fc32
    uri: usb:1.8.5
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: LOFreq
    gain1: '''manual'''
    manual_gain1: '0'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: USB
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: LOFreq
    fftsize: '2048'
    name: ''
    plotconst: 'False'
    plotwaterfall: 'False'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
