options:
  parameters:
    generate_options: qt_gui
    id: Example1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Amp
  id: variable_qtgui_range
  parameters:
    start: '0.001'
    step: '0.01'
    stop: '1'
    value: '0.001'
  states: {}
- name: LOFreq
  id: variable
  parameters:
    value: int(5.3e9)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '800000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: LOFreq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(2e6)
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: LOFreq
    fftsize: '2048'
    name: ''
    plotconst: 'False'
    plotwaterfall: 'False'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
