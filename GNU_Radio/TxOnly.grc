options:
  parameters:
    generate_options: qt_gui
    id: Example1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: LOFreq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '70000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: LOFreq
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
